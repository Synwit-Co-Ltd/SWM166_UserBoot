# Keil uVision project SWM166_StdPeriph_Driver.uvprojx, settings and files
target SWM166 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM166x8 Synwit
  pack: Synwit.SWM32_DFP.2.0.8
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: SWM166_APP
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 v6Lang=3 v6LangP=1
  c define: CHIP_SWM166
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM166_StdPeriph_Driver
  asm define: CHIP_SWM166
  library: MicroLIB
  memory RVCT4: ROM 0x4000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ./app/: main.c
    ./APP/: remap.c
  group CSL\StdPD
    ./CSL/SWM166_StdPeriph_Driver/: SWM166_port.c SWM166_gpio.c SWM166_exti.c SWM166_timr.c SWM166_uart.c SWM166_adc.c SWM166_i2c.c SWM166_pwm.c SWM166_wdt.c SWM166_sleep.c SWM166_div.c SWM166_cordic.c SWM166_spi.c SWM166_qei.c SWM166_dma.c SWM166_can.c SWM166_flash.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM166.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM166.s
